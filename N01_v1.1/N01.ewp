# IAR project N01.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L052R8 STM8L052R8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L15X_HD
  ICCSTM8.CCIncludePath2: lib\inc; lib\src; user; user\RFID
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: N01.bin
  ILINK.IlinkOutputFile: N01.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group lib
    lib/src/: delay.c eeprom.c stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_it.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
  group user
    user/: adc.c DynamicPassword.c iwdg.c Key.c lock.c main.c rtc.c save.c spi.c SYS_CLOCK.c TIM.c uart.c
  group user/sky1311t
    user/RFID/: cardoper.c iso14443a.c iso14443b.c mifare1.c RFID.c sky1311_drv.c sky1311t.c
